# Keil uVision project ucosii_Qitas.uvprojx, settings and files
target ucosii (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ucosii_Qitas +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CM3;..\CMSIS\ST;..\CMSIS\ST\LIB\inc;..\SYSTEM;..\USER;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORTS;..\HARDWARE;..\HARDWARE\LED
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/CM3/: core_cm3.c
    ../CMSIS/ST/STARTUP/: startup_stm32f10x_hd.s
    ../CMSIS/ST/: stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../CMSIS/ST/LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c jlink_printf.c
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
  group UCOSII_CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORTS
    ../UCOSII/PORTS/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOSII_CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
